# IAR project FPU_Math.ewp, settings and files
configuration APM32F103 (ARM, debug)
  General.OGChipSelectEditMenu: APM32F103ZE Geehy APM32F103ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: APM32F10X_HD; APM32F103_MINI
  ICCARM.CCIncludePath2: ..\..\Include; ..\..\..\..\..\Board; ..\..\..\..\..\Library\APM32F10x_StdPeriphDriver\inc; ..\..\..\..\..\Library\CMSIS\Include; ..\..\..\..\..\Library\Device\Geehy\APM32F10x\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: FPU_Math.out
  ILINK.IlinkAdditionalLibs: ..\..\Source\sc_math.lib; ..\..\Source\sc_dot.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../Source/: apm32f10x_int.c main.c
  group Board
    ../../../../../Board/: Board.c
  group CMSIS
    ../../../../../Library/Device/Geehy/APM32F10x/Source/iar/: startup_apm32f10x_hd.s startup_apm32f10x_md.s
    ../../../../../Library/Device/Geehy/APM32F10x/Source/: system_apm32f10x.c
  group StdPeriphDriver
    ../../../../../Library/APM32F10x_StdPeriphDriver/src/: apm32f10x_adc.c apm32f10x_bakpr.c apm32f10x_can.c apm32f10x_crc.c apm32f10x_dac.c apm32f10x_dbgmcu.c apm32f10x_dma.c apm32f10x_dmc.c apm32f10x_eint.c apm32f10x_emmc.c apm32f10x_fmc.c apm32f10x_gpio.c apm32f10x_i2c.c apm32f10x_iwdt.c apm32f10x_misc.c apm32f10x_pmu.c apm32f10x_qspi.c apm32f10x_rcm.c apm32f10x_rtc.c apm32f10x_sci2c.c apm32f10x_sdio.c apm32f10x_spi.c apm32f10x_tmr.c apm32f10x_usart.c apm32f10x_wwdt.c
