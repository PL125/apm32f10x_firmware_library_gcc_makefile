# Keil uVision project USB_MSC_Disk.uvprojx, settings and files
target APM32F103 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: APM32F103ZE Geehy
  pack: Geehy.APM32F1xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USB_MSC_Disk
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: APM32F10X_HD,APM32F103_MINI
  c include: ..\..\Include;..\..\..\..\..\Board;..\..\..\..\..\Library\APM32F10x_StdPeriphDriver\inc;..\..\..\..\..\Library\CMSIS\Include;..\..\..\..\..\Library\Device\Geehy\APM32F10x\Include;..\..\..\..\..\Library\USB_Device_Lib\Core_Device\Class\MSC\inc;..\..\..\..\..\Library\USB_Device_Lib\Core_Device\Standard\inc;..\..\..\..\..\Library\USB_Device_Lib\Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application
    ../../Source/: main.c apm32f10x_int.c
  group APP/MSC
    ../../Source/: usbd_storage_disk.c usbd_msc.c usbd_descriptor.c usb_bsp.c
    ../../../../../Library/USB_Device_Lib/Core_Device/Class/MSC/src/: usbd_class_msc.c usbd_msc_bot.c usbd_msc_scsi.c
  group USB_Protocol
    ../../../../../Library/USB_Device_Lib/Core_Device/Standard/src/: usbd_init.c usbd_core.c usbd_interrupt.c usbd_stdReq.c
  group USB_Driver
    ../../../../../Library/USB_Device_Lib/Driver/src/: drv_usb_device.c
  group Board
    ../../../../../Board/: Board.c
  group StdPeriphDriver
    ../../../../../Library/APM32F10x_StdPeriphDriver/src/: apm32f10x_adc.c apm32f10x_bakpr.c apm32f10x_can.c apm32f10x_crc.c apm32f10x_dac.c apm32f10x_dbgmcu.c apm32f10x_dma.c apm32f10x_dmc.c apm32f10x_eint.c apm32f10x_emmc.c apm32f10x_fmc.c apm32f10x_gpio.c apm32f10x_i2c.c apm32f10x_iwdt.c apm32f10x_misc.c apm32f10x_pmu.c apm32f10x_qspi.c apm32f10x_rcm.c apm32f10x_rtc.c apm32f10x_sci2c.c apm32f10x_sdio.c apm32f10x_spi.c apm32f10x_tmr.c apm32f10x_usart.c apm32f10x_wwdt.c
  group CMSIS
    ../../../../../Library/Device/Geehy/APM32F10x/Source/: system_apm32f10x.c
    ../../../../../Library/Device/Geehy/APM32F10x/Source/arm/: startup_apm32f10x_hd.s startup_apm32f10x_md.s
