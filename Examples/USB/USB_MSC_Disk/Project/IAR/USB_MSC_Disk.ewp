# IAR project USB_MSC_Disk.ewp, settings and files
configuration APM32F103 (ARM, debug)
  General.OGChipSelectEditMenu: APM32F103ZE Geehy APM32F103ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: APM32F10X_HD; APM32F103_MINI
  ICCARM.CCIncludePath2: ..\..\Include; ..\..\..\..\..\Board; ..\..\..\..\..\Library\APM32F10x_StdPeriphDriver\inc; ..\..\..\..\..\Library\CMSIS\Include; ..\..\..\..\..\Library\Device\Geehy\APM32F10x\Include; ..\..\..\..\..\Library\USB_Device_Lib\Core_Device\Standard\inc; ..\..\..\..\..\Library\USB_Device_Lib\Core_Device\Class\MSC\inc; ..\..\..\..\..\Library\USB_Device_Lib\Driver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: USB_MSC_Disk.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group APP/MSC
    ../../Source/: usb_bsp.c usbd_descriptor.c usbd_msc.c usbd_storage_disk.c
    ../../../../../Library/USB_Device_Lib/Core_Device/Class/MSC/src/: usbd_class_msc.c usbd_msc_bot.c usbd_msc_scsi.c
  group Application
    ../../Source/: apm32f10x_int.c main.c
  group Board
    ../../../../../Board/: Board.c
  group CMSIS
    ../../../../../Library/Device/Geehy/APM32F10x/Source/iar/: startup_apm32f10x_hd.s startup_apm32f10x_md.s
    ../../../../../Library/Device/Geehy/APM32F10x/Source/: system_apm32f10x.c
  group StdPeriphDriver
    ../../../../../Library/APM32F10x_StdPeriphDriver/src/: apm32f10x_adc.c apm32f10x_bakpr.c apm32f10x_can.c apm32f10x_crc.c apm32f10x_dac.c apm32f10x_dbgmcu.c apm32f10x_dma.c apm32f10x_dmc.c apm32f10x_eint.c apm32f10x_emmc.c apm32f10x_fmc.c apm32f10x_gpio.c apm32f10x_i2c.c apm32f10x_iwdt.c apm32f10x_misc.c apm32f10x_pmu.c apm32f10x_qspi.c apm32f10x_rcm.c apm32f10x_rtc.c apm32f10x_sci2c.c apm32f10x_sdio.c apm32f10x_spi.c apm32f10x_tmr.c apm32f10x_usart.c apm32f10x_wwdt.c
  group USB_Driver
    ../../../../../Library/USB_Device_Lib/Driver/src/: drv_usb_device.c
  group USB_Protocol
    ../../../../../Library/USB_Device_Lib/Core_Device/Standard/src/: usbd_core.c usbd_init.c usbd_interrupt.c usbd_stdReq.c
